# Keil uVision project STM32F407.uvprojx, settings and files
target STM32F407 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F429 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,
  c include: ..\STM32\CMSIS\Device\ST\STM32F4xx\Include;..\STM32\CMSIS\Include;..\STM32\STM32F4xx_StdPeriph_Driver\inc;..\MY;..\Drive\Include;..\Drive\Source
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group MY
    ../MY/: main.c stm32f4xx_it.c stm32f4xx_conf.h
  group Drive
    ../Drive/Source/: led.c delay.c key.c usart.c lcd_fonts.c lcd_image.c lcd_spi_154.c ad.c ad8232.c timer.c usart2.c esp8266.c ecg_key.c bsp_led.c beep.c ecg_sim.c display.c transmit.c
  group STM32
    ../STM32/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
    ../STM32/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../STM32/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_rcc.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_spi.c stm32f4xx_adc.c stm32f4xx_tim.c
